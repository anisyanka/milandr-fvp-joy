# IAR project HelloWorld_K1986VE92xI.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: K1986VE92xI Milandr K1986VE92xI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_K1986VE92xI
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\MDR32FxQI\CoreSupport\CM3; ..\..\Libraries\CMSIS\MDR32FxQI\DeviceSupport\K1986VE9xI\inc; ..\..\Libraries\CMSIS\MDR32FxQI\DeviceSupport\K1986VE9xI\startup; ..\..\Libraries\SPL\MDR32FxQI\inc; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HelloWorld_1986VE92.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_K1986VE92xI
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: HelloWorld_1986VE92.hex
  group Drivers
    ../../Libraries/SPL/MDR32FxQI/src/: MDR32FxQI_port.c MDR32FxQI_rst_clk.c
  group src
    ./: main.c
  group Startup
    ../../Libraries/CMSIS/MDR32FxQI/DeviceSupport/K1986VE9xI/startup/iar/: startup_K1986VE9xI.S
    ../../Libraries/CMSIS/MDR32FxQI/DeviceSupport/K1986VE9xI/startup/: system_K1986VE9xI.c system_K1986VE9xI.h
