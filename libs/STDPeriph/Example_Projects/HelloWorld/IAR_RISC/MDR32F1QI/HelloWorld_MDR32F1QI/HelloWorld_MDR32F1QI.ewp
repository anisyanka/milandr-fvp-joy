# IAR project HelloWorld_MDR32F1QI.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR32F1QI Milandr MDR32F1QI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 36
  General.FPU2: 0
  ICCARM.CCDefines: USE_MDR32F1QI_REV6
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\MDR32FxQI\CoreSupport\CM1; ..\..\Libraries\CMSIS\MDR32FxQI\DeviceSupport\MDR32F1QI\inc; ..\..\Libraries\CMSIS\MDR32FxQI\DeviceSupport\MDR32F1QI\startup; ..\..\Libraries\SPL\MDR32FxQI\inc; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HelloWorld_1986VE1.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG; USE_MDR32F1QI_REV6
  ICCARM.CCOptLevel: 3
  group Drivers
    ../../Libraries/SPL/MDR32FxQI/src/: MDR32FxQI_port.c MDR32FxQI_rst_clk.c
  group src
    ./: main.c
  group Startup
    ../../Libraries/CMSIS/MDR32FxQI/DeviceSupport/MDR32F1QI/startup/iar/: startup_MDR32F1QI.S
    ../../Libraries/CMSIS/MDR32FxQI/DeviceSupport/MDR32F1QI/startup/: system_MDR32F1QI.c system_MDR32F1QI.h
