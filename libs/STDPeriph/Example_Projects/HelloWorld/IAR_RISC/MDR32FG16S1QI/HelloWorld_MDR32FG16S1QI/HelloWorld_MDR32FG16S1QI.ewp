# IAR project HelloWorld_MDR32FG16S1QI.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR32FG16S1QI Milandr MDR32FG16S1QI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_MDR32FG16S1QI
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\MDR32FxQI\CoreSupport\CM3; ..\..\Libraries\CMSIS\MDR32FxQI\DeviceSupport\MDR32FG16S1QI\inc; ..\..\Libraries\CMSIS\MDR32FxQI\DeviceSupport\MDR32FG16S1QI\startup; ..\..\Libraries\SPL\MDR32FxQI\inc; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_MDR32FG16S1QI
  ICCARM.CCOptLevel: 3
  group Drivers
    ../../Libraries/SPL/MDR32FxQI/src/: MDR32FxQI_port.c MDR32FxQI_rst_clk.c
  group src
    ./: main.c
  group Startup
    ../../Libraries/CMSIS/MDR32FxQI/DeviceSupport/MDR32FG16S1QI/startup/iar/: startup_MDR32FG16S1QI.S
    ../../Libraries/CMSIS/MDR32FxQI/DeviceSupport/MDR32FG16S1QI/startup/: system_MDR32FG16S1QI.c system_MDR32FG16S1QI.h
